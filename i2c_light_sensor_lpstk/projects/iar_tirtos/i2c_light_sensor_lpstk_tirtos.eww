<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\i2c_light_sensor_lpstk_tirtos.ewp</path>
  </project>
  <batchBuild/>
</workspace>


