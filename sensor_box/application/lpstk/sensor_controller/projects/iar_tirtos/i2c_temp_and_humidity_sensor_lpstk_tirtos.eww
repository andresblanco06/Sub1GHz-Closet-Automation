<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\i2c_temp_and_humidity_sensor_lpstk_tirtos.ewp</path>
  </project>
  <batchBuild/>
</workspace>


