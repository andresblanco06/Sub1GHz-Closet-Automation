# IAR project i2c_temp_and_humidity_sensor_lpstk_tirtos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC1352R1F3 TexasInstruments CC1352R1F3
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 4
  ICCARM.CCDefines: DEVICE_FAMILY=cc13x2_cc26x2; DeviceFamily_CC13X2; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f configPkg/compiler.opt.defs
  ICCARM.CCIncludePath2: C:\ti\simplelink_cc13x2_26x2_sdk_4_10_00_78\source; C:\ti\simplelink_cc13x2_26x2_sdk_4_10_00_78\packages; C:\ti\simplelink_cc13x2_26x2_sdk_4_10_00_78\source\ti\boards\CC1352R1_LAUNCHXL
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: i2c_temp_and_humidity_sensor_lpstk_tirtos.srec
  prebuild: "C:\ti\xdctools_3_61_00_16_core\xs" --xdcpath="C:\ti\simplelink_cc13x2_26x2_sdk_4_10_00_78\source;C:\ti\simplelink_cc13x2_26x2_sdk_4_10_00_78\kernel\tirtos\packages;C:\ti\simplelink_cc13x2_26x2_sdk_4_10_00_78\source\ti\drivers" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: i2c_temp_and_humidity_sensor_lpstk_tirtos.out
  ILINK.IlinkConfigDefines: RTOS_ROM=1
  ILINK.IlinkIcfFile: C:\ti\simplelink_cc13x2_26x2_sdk_4_10_00_78\source\ti\boards\CC1352R1_LAUNCHXL\CC1352R1_LAUNCHXL_TIRTOS.icf
  ILINK.IlinkExtraOptions: -f configPkg/linker.cmd
  ILINK.IlinkAdditionalLibs: C:\ti\simplelink_cc13x2_26x2_sdk_4_10_00_78\source\ti\devices\cc13x2_cc26x2\driverlib\bin\iar\driverlib.lib; C:\ti\simplelink_cc13x2_26x2_sdk_4_10_00_78\source\ti\drivers\lib\drivers_cc13x2.arm4f; C:\ti\simplelink_cc13x2_26x2_sdk_4_10_00_78\kernel\tirtos\packages\ti\dpl\lib\dpl_cc13x2.arm4f
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: rom.cfg
    ../../source/: scif.c scif.h scif_framework.c scif_framework.h scif_osal_tirtos.h main_tirtos.c
  group sdk_files__do_not_edit
    C:/ti/simplelink_cc13x2_26x2_sdk_4_10_00_78/source/ti/boards/CC1352R1_LAUNCHXL/: CC1352R1_LAUNCHXL.c Board.h CC1352R1_LAUNCHXL_fxns.c
    C:/ti/simplelink_cc13x2_26x2_sdk_4_10_00_78/source/ti/devices/cc13x2_cc26x2/startup_files/: ccfg.c
